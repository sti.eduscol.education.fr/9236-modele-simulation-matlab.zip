simulink model "TableVerin4position2BO_Montee_S"  (R2013b)
settings: Solver=ode15s  StartTime=0.0  StopTime=20  RelTol=1e-3
undefined symbols (not defined in the file): deg, kg, m, mm, N, rad, s, X, Y, Z
libraries: sm_lib x907, fl_lib x19, nesl_utility x13, elec_lib x3, sdl_lib x2
(part 17 of 18)

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_1_RIGID/x15060_NLM_Poign_e_Miniwing_M6_06652_006_X_15_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0031415499999999999  MassUnits=kg  CenterOfMass=[0 5.4933500000000004 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.151592 0.116684 0.22078500000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0.0064548499999999998 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-PoignÚe Miniwing M6 - 06652-006 X 15_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_1_RIGID/x15060_Rondelle_Rondelle_Etroite_Z_4_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=3.9276200000000002e-05  MassUnits=kg  CenterOfMass=[0 0.40000000000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.000246319 0.00048844899999999996 0.000246319]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Etroite Z 4_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_1_RIGID/x15060_Rondelle_Rondelle_Etroite_Z_4_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=3.9276200000000002e-05  MassUnits=kg  CenterOfMass=[0 0.40000000000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.000246319 0.00048844899999999996 0.000246319]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Etroite Z 4_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_1_RIGID/x15060_Rondelle_Rondelle_Etroite_Z_4_3_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=3.9276200000000002e-05  MassUnits=kg  CenterOfMass=[0 0.40000000000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.000246319 0.00048844899999999996 0.000246319]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Etroite Z 4_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_M_01029_Plaquette_haute_sur_glissiere_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.16431999999999999  MassUnits=kg  CenterOfMass=[-0.63256999999999997 23.438800000000001 4.9895300000000002]  CenterOfMassUnits=mm  MomentsOfInertia=[87.900999999999996 87.570599999999999 172.749]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0.0346898 -0.044105600000000002 2.4036900000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01029-Plaquette haute sur glissiere_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_M_01042_Barre_transversale_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.60250400000000004  MassUnits=kg  CenterOfMass=[0 0 -1.04198e-12]  CenterOfMassUnits=mm  MomentsOfInertia=[20808.599999999999 20753.200000000001 65.337600000000009]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01042-Barre transversale_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_M_01043_Bride_de_barre_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0646534  MassUnits=kg  CenterOfMass=[0 -0.40050599999999997 5.0587200000000001]  CenterOfMassUnits=mm  MomentsOfInertia=[5.7510300000000001 34.636699999999998 39.315600000000003]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0.038467100000000004 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01043-Bride de barre_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_M_01043_Bride_de_barre_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0646534  MassUnits=kg  CenterOfMass=[0 -0.40050599999999997 5.0587200000000001]  CenterOfMassUnits=mm  MomentsOfInertia=[5.7510300000000001 34.636699999999998 39.315600000000003]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0.038467100000000004 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01043-Bride de barre_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_M_01053_Plaquette_haute_sur_glissiere_SYM_AA_DEFAULT_1_R ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.16431999999999999  MassUnits=kg  CenterOfMass=[-0.632606 23.438800000000001 -4.9895300000000002]  CenterOfMassUnits=mm  MomentsOfInertia=[87.900800000000004 87.570599999999999 172.749]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.0346886 0.044093199999999999 2.4038600000000003]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01053-Plaquette haute sur glissiere - SYM_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_NLM_Goupille_cyl_3_Lgr_16_03320_03x16_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.000113097  MassUnits=kg  CenterOfMass=[8 0 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.00012723500000000001 0.0024763599999999999 0.0024763599999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Goupille cyl Ï3 Lgr 16 - 03320-03x16_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_NLM_Goupille_cyl_3_Lgr_16_03320_03x16_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.000113097  MassUnits=kg  CenterOfMass=[8 0 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.00012723500000000001 0.0024763599999999999 0.0024763599999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Goupille cyl Ï3 Lgr 16 - 03320-03x16_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_NLM_Poign_e_Miniwing_M6_06652_006_X_15_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0031415499999999999  MassUnits=kg  CenterOfMass=[0 5.4933500000000004 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.151592 0.116684 0.22078500000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0.0064548499999999998 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-PoignÚe Miniwing M6 - 06652-006 X 15_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_NLM_Poign_e_Miniwing_M6_06652_006_X_15_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0031415499999999999  MassUnits=kg  CenterOfMass=[0 5.4933500000000004 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.151592 0.116684 0.22078500000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0.0064548499999999998 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-PoignÚe Miniwing M6 - 06652-006 X 15_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_Rondelle_Rondelle_Etroite_Z_4_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=3.9276200000000002e-05  MassUnits=kg  CenterOfMass=[0 0.40000000000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.000246319 0.00048844899999999996 0.000246319]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Etroite Z 4_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_Rondelle_Rondelle_Etroite_Z_4_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=3.9276200000000002e-05  MassUnits=kg  CenterOfMass=[0 0.40000000000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.000246319 0.00048844899999999996 0.000246319]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Etroite Z 4_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID/x15060_Rondelle_Rondelle_Etroite_Z_4_3_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=3.9276200000000002e-05  MassUnits=kg  CenterOfMass=[0 0.40000000000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.000246319 0.00048844899999999996 0.000246319]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Etroite Z 4_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_1_RIGID/x15060_NLM_Palier_flottant_21230_2711_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_1_RIGID/x15060_NLM_Palier_flottant_21230_2711_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_1_RIGID/x15060_NLM_Palier_flottant_21230_2711_3_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_1_RIGID/x15060_NLM_Palier_flottant_21230_2711_4_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_1_RIGID/x15060_NLM_Rail_21230_2730_X_Lgr_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.068416199999999996  MassUnits=kg  CenterOfMass=[390 3.0880299999999998 0]  CenterOfMassUnits=mm  MomentsOfInertia=[4.6660399999999997 2573.8499999999999 2569.9400000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Rail - 21230-2730 X Lgr._Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_2_RIGID/x15060_NLM_Palier_flottant_21230_2711_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_2_RIGID/x15060_NLM_Palier_flottant_21230_2711_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_2_RIGID/x15060_NLM_Palier_flottant_21230_2711_3_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_NLM_Ens_guidage_Drylin_N_1_Default_2_RIGID/x15060_NLM_Palier_flottant_21230_2711_4_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0034336600000000003  MassUnits=kg  CenterOfMass=[20 6.8081300000000002 0.063214900000000004]  CenterOfMassUnits=mm  MomentsOfInertia=[0.14834700000000001 0.51841599999999999 0.39706900000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00033843699999999997 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Palier flottant - 21230-2711_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1
