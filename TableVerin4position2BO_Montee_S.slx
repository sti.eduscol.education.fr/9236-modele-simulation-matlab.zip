simulink model "TableVerin4position2BO_Montee_S"  (R2013b)
settings: Solver=ode15s  StartTime=0.0  StopTime=20  RelTol=1e-3
undefined symbols (not defined in the file): deg, kg, m, mm, N, rad, s, X, Y, Z
libraries: sm_lib x907, fl_lib x19, nesl_utility x13, elec_lib x3, sdl_lib x2
(part 10 of 18)

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_M_01063_Rondelle_entretoise_AA_DEFAULT_4_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0012337000000000001  MassUnits=kg  CenterOfMass=[0 0.5 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.046058299999999996 0.091910900000000004 0.046058299999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01063-Rondelle entretoise_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_M_01063_Rondelle_entretoise_AA_DEFAULT_5_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0012337000000000001  MassUnits=kg  CenterOfMass=[0 0.5 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.046058299999999996 0.091910900000000004 0.046058299999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01063-Rondelle entretoise_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_M_01069_Bride_doigt_dindexage_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.014447099999999999  MassUnits=kg  CenterOfMass=[4.4069700000000003 -2.6008199999999997 -4.1192499999999998e-07]  CenterOfMassUnits=mm  MomentsOfInertia=[1.8820299999999999 2.6811400000000001 3.4835000000000003]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-6.5011099999999991e-08 -4.9180400000000003e-08 -0.603711]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01069-Bride doigt d''indexage_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_M_01075_Broche_M12_Modifi_e_27810_120451_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0047747900000000001  MassUnits=kg  CenterOfMass=[-3.6256400000000002 5.7239899999999995e-11 9.2095899999999998e-10]  CenterOfMassUnits=mm  MomentsOfInertia=[0.104488 0.560944 0.56094299999999997]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01075-Broche M12 ModifiÚe - 27810-120451_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_NLM_Doigt_dindexage_acier_6_avec_contre_ecrou_M12x1_5_03 ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0088640300000000002  MassUnits=kg  CenterOfMass=[0 31.310499999999998 0]  CenterOfMassUnits=mm  MomentsOfInertia=[2.5645000000000002 0.33363399999999999 2.5645000000000002]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-NLM-Doigt d''indexage acier Ï6 avec contre ecrou M12x1.5  - 03089-2206_AA - DEFAULT_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_NLM_Embase_60_27801_20601_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0412567  MassUnits=kg  CenterOfMass=[3.1516899999999996e-05 6.0550100000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[9.1015499999999996 16.328600000000002 9.1015499999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 5.7797099999999998e-06]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Embase Ï 60 - 27801-20601_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_NLM_Roulette_pivotante_F_200_KG_95034_07532_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.14865700000000001  MassUnits=kg  CenterOfMass=[18.544499999999999 28.657700000000002 2.3950599999999997e-05]  CenterOfMassUnits=mm  MomentsOfInertia=[170.20699999999999 146.78099999999998 227.70599999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-5.38496e-05 -0.00156548 63.646399999999993]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Roulette pivotante F 200 KG - 95034-07532_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_NLM_Verin_a_levier_Rot_a_droite_traction_04410_35_1_RIGI ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.147758  MassUnits=kg  CenterOfMass=[-26.9514 18.9069 18.9069]  CenterOfMassUnits=mm  MomentsOfInertia=[376.55899999999997 216.44699999999997 216.44699999999997]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[165.25200000000001 2.65794 2.65794]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Verin a levier - Rot a droite - traction - 04410-35_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_Rondelle_Rondelle_Large_L_6_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.00026675899999999998  MassUnits=kg  CenterOfMass=[0 0.60000000000000009 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.0061167799999999996 0.0121695 0.0061167799999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Large L 6_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_Vis_CHc_vis_CHc_M_5_X_20_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0048238700000000001  MassUnits=kg  CenterOfMass=[0 1.34757e-08 10.3775]  CenterOfMassUnits=mm  MomentsOfInertia=[0.28694200000000003 0.28696100000000002 0.0276957]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 -1.2488400000000001e-06]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-Vis CHc-_vis CHc M 5 X  20_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_Vis_CHc_vis_CHc_M_6_X_16_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0063984299999999992  MassUnits=kg  CenterOfMass=[0 2.0673599999999999e-08 9.0782100000000003]  CenterOfMassUnits=mm  MomentsOfInertia=[0.29070799999999997 0.290742 0.057109699999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 -3.3171899999999999e-06]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-Vis CHc-_vis CHc M 6 X  16_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_Vis_CHc_vis_CHc_M_8_X_12_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.011420700000000001  MassUnits=kg  CenterOfMass=[0 3.49975e-08 8.2269400000000008]  CenterOfMassUnits=mm  MomentsOfInertia=[0.44194499999999998 0.44202999999999998 0.19711100000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-1.1012799999999999e-09 0 -7.9529199999999994e-06]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-Vis CHc-_vis CHc M 8 X  12_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_Vis_CHc_vis_CHc_M_8_X_25_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.016451799999999999  MassUnits=kg  CenterOfMass=[0 2.4702000000000002e-08 13.7873]  CenterOfMassUnits=mm  MomentsOfInertia=[1.6874800000000001 1.6876200000000001 0.23733199999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-1.56056e-09 0 -1.31232e-05]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-Vis CHc-_vis CHc M 8 X  25_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_4_RIGID/x15060_Vis_CHc_vis_CHc_M_8_X_25_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.016451799999999999  MassUnits=kg  CenterOfMass=[0 2.4702000000000002e-08 13.7873]  CenterOfMassUnits=mm  MomentsOfInertia=[1.6874800000000001 1.6876200000000001 0.23733199999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-1.56056e-09 0 -1.31232e-05]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-Vis CHc-_vis CHc M 8 X  25_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01009_Ens_chassis_inf_Default_1_RIGID/x15060_ITEM_Kit_Equerre_8_40x40_Zn_0_0_411_15_AA_DEFAULT_1_RIGI ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.010278799999999999  MassUnits=kg  CenterOfMass=[11.6701 11.6701 0]  CenterOfMassUnits=mm  MomentsOfInertia=[3.3914200000000001 3.3914200000000001 2.6288999999999998]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 -0.71321800000000002]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-ITEM-Kit Equerre 8 40x40 Zn - 0.0.411.15_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01009_Ens_chassis_inf_Default_1_RIGID/x15060_ITEM_Kit_Equerre_8_40x40_Zn_0_0_411_15_AA_DEFAULT_2_RIGI ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.010278799999999999  MassUnits=kg  CenterOfMass=[11.6701 11.6701 0]  CenterOfMassUnits=mm  MomentsOfInertia=[3.3914200000000001 3.3914200000000001 2.6288999999999998]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 -0.71321800000000002]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-ITEM-Kit Equerre 8 40x40 Zn - 0.0.411.15_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01009_Ens_chassis_inf_Default_1_RIGID/x15060_ITEM_Kit_Equerre_8_40x40_Zn_0_0_411_15_AA_DEFAULT_3_RIGI ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.010278799999999999  MassUnits=kg  CenterOfMass=[11.6701 11.6701 0]  CenterOfMassUnits=mm  MomentsOfInertia=[3.3914200000000001 3.3914200000000001 2.6288999999999998]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 -0.71321800000000002]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-ITEM-Kit Equerre 8 40x40 Zn - 0.0.411.15_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01009_Ens_chassis_inf_Default_1_RIGID/x15060_ITEM_Kit_Equerre_8_40x40_Zn_0_0_411_15_AA_DEFAULT_4_RIGI ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.010278799999999999  MassUnits=kg  CenterOfMass=[11.6701 11.6701 0]  CenterOfMassUnits=mm  MomentsOfInertia=[3.3914200000000001 3.3914200000000001 2.6288999999999998]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 -0.71321800000000002]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-ITEM-Kit Equerre 8 40x40 Zn - 0.0.411.15_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01009_Ens_chassis_inf_Default_1_RIGID/x15060_M_01023_Chassis_alu_partie_basse_AA_DEFAULT_Brut_dusinag ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=14.0756  MassUnits=kg  CenterOfMass=[-871.22799999999995 -7.3215199999999996 -17.4803]  CenterOfMassUnits=mm  MomentsOfInertia=[1185070 3863170 5031570]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[259.66499999999996 398.21200000000005 16877.5]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01023-Chassis alu partie basse_AA - DEFAULT_Brut d''usinage__Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01013_Ens_Coffret_electrique_sous_table_Default_1_RIGI/x15060_Bouton_rouge_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.053374600000000001  MassUnits=kg  CenterOfMass=[-15.683400000000001 5.2633499999999996e-09 0]  CenterOfMassUnits=mm  MomentsOfInertia=[12.472299999999999 13.848599999999999 17.9161]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-1.15981e-05 0 2.24736e-09]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Bouton rouge-_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01013_Ens_Coffret_electrique_sous_table_Default_1_RIGI/x15060_Bouton_vert_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.053374600000000001  MassUnits=kg  CenterOfMass=[-15.683400000000001 5.2633499999999996e-09 0]  CenterOfMassUnits=mm  MomentsOfInertia=[12.472299999999999 13.848599999999999 17.9161]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-1.15981e-05 0 2.24736e-09]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Bouton vert-_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01013_Ens_Coffret_electrique_sous_table_Default_1_RIGI/x15060_Coffret_elect_600_X_300_H_150_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=3.3824200000000002  MassUnits=kg  CenterOfMass=[0.97959399999999985 3.40137 86.472499999999997]  CenterOfMassUnits=mm  MomentsOfInertia=[137229 44256.5 172087]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-649.70799999999997 -187.11599999999999 1024.1700000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Coffret elect - 600 X 300 H 150_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01018_Ch_ssis_bas_1_RIGID/x15060_Ecrou_22_Ecrou_Hm_M12_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.00136582  MassUnits=kg  CenterOfMass=[0 3 3.6598700000000002e-10]  CenterOfMassUnits=mm  MomentsOfInertia=[0.0470239 0.085997299999999999 0.0470239]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Ecrou-_22 - Ecrou Hm M12_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01018_Ch_ssis_bas_1_RIGID/x15060_M_01015_Ens_verin_levage_Default_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Transform : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-517.07099999999991 35.420000000000002 16.307499999999997]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.6424450276988594  RotationArbitraryAxis=[-0.25846666391264611 0.25846666391264667 -0.9308007129841136]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  F : PMIOPort  Port=1  Side=Right
  connections:
  ReferenceFrame/RConn1 -- Transform/RConn1
  Transform/LConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01018_Ch_ssis_bas_1_RIGID/x15060_M_01016_Ens_verin_inclinaison_Default_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Transform : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-534.86299999999994 -149.5 81.105599999999995]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=0.9229778637121423  RotationArbitraryAxis=[1.4239367345454361e-15 1 -3.9495448970531802e-16]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  F : PMIOPort  Port=1  Side=Right
  connections:
  ReferenceFrame/RConn1 -- Transform/RConn1
  Transform/LConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01018_Ch_ssis_bas_1_RIGID/x15060_M_01026_Chape_basse_AA_DEFAULT_Brut_dusinage_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=16.916799999999999  MassUnits=kg  CenterOfMass=[18.3353 0.98298000000000008 -88.729100000000003]  CenterOfMassUnits=mm  MomentsOfInertia=[178409 255724.99999999997 382080]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-31819.800000000003 2854.8599999999997 -14403.900000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01026-Chape basse_AA - DEFAULT_Brut d''usinage__Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1
