simulink model "TableVerin4position2BO_Montee_S"  (R2013b)
settings: Solver=ode15s  StartTime=0.0  StopTime=20  RelTol=1e-3
undefined symbols (not defined in the file): deg, kg, m, mm, N, rad, s, X, Y, Z
libraries: sm_lib x907, fl_lib x19, nesl_utility x13, elec_lib x3, sdl_lib x2
(part 13 of 18)

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01005_Ens_barre_de_cadre_2_Default_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Transform : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=None  TranslationLengthUnit=m  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[0 0 0]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=None  RotationAngleUnits=deg  RotationStandardAxis=+Z  RotationAngle=0  RotationArbitraryAxis=[0 0 1]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform1 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[42.5 56.5 -326]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.7467406108938903  RotationArbitraryAxis=[-0.3859580756948327 -0.38595807569483265 0.83789780260595248]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform10 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[10 0 321]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.5777292164721624  RotationArbitraryAxis=[-0.99309103220519346 0.082976507981545794 -0.082976507981545988]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform11 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[25 72.5 336.75]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897931  RotationArbitraryAxis=[1.6314226234179785e-16 -0.70710678118654746 0.70710678118654757]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform12 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-172.11399999999998 -22.5 7.2534699999999998e-09]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897931  RotationArbitraryAxis=[6.9389e-17 1 -1.8504500000000001e-16]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform2 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[25 0 -331]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897931  RotationArbitraryAxis=[0 1 0]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform3 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[25 77.5 -346.5]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=0.95951428278210815  RotationArbitraryAxis=[0 1 0]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform4 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[7.5 56.5 -326]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.7467406108938903  RotationArbitraryAxis=[-0.3859580756948327 -0.38595807569483265 0.83789780260595248]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform5 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-10 0 -320.19999999999999]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.5777292164721624  RotationArbitraryAxis=[-0.99309103220519346 0.082976507981545794 -0.082976507981545988]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform6 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[25 0 331]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897931  RotationArbitraryAxis=[-1.110225e-16 1 0]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform7 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[25 77.5 346.5]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.5193660168733383  RotationArbitraryAxis=[0 -1 0]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform8 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[25 72.5 -336.75]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.5707963267948968  RotationArbitraryAxis=[1 6.0715499999999988e-17 -6.0715499999999988e-17]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform9 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-10 0 321]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.5777292164721624  RotationArbitraryAxis=[-0.99309103220519346 0.082976507981545794 -0.082976507981545988]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  x15060_M_01029_Plaquette_haute_sur_glissiere_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01042_Barre_transversale_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01043_Bride_de_barre_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01043_Bride_de_barre_AA_DEFAULT_2_RIGID : Subsystem
  x15060_M_01053_Plaquette_haute_sur_glissiere_SYM_AA_DEFAULT_1_R : Subsystem
  x15060_NLM_Goupille_cyl_3_Lgr_16_03320_03x16_AA_DEFAULT_1_RIGID : Subsystem
  x15060_NLM_Goupille_cyl_3_Lgr_16_03320_03x16_AA_DEFAULT_2_RIGID : Subsystem
  x15060_NLM_Poign_e_Miniwing_M6_06652_006_X_15_1_RIGID : Subsystem
  x15060_NLM_Poign_e_Miniwing_M6_06652_006_X_15_2_RIGID : Subsystem
  x15060_Rondelle_Rondelle_Etroite_Z_4_1_RIGID : Subsystem
  x15060_Rondelle_Rondelle_Etroite_Z_4_2_RIGID : Subsystem
  x15060_Rondelle_Rondelle_Etroite_Z_4_3_RIGID : Subsystem
  F : PMIOPort  Port=1  Side=Right
  connections:
  Transform/RConn1 -- x15060_M_01042_Barre_transversale_AA_DEFAULT_1_RIGID/LConn1
  Transform1/RConn1 -- x15060_NLM_Goupille_cyl_3_Lgr_16_03320_03x16_AA_DEFAULT_1_RIGID/LConn1
  Transform10/RConn1 -- x15060_Rondelle_Rondelle_Etroite_Z_4_3_RIGID/LConn1
  Transform11/RConn1 -- x15060_M_01043_Bride_de_barre_AA_DEFAULT_2_RIGID/LConn1
  Transform/LConn1 -- ReferenceFrame/RConn1 -- Transform1/LConn1 -- Transform10/LConn1 -- Transform11/LConn1 -- Transform12/RConn1 -- Transform2/LConn1 -- Transform3/LConn1 -- Transform4/LConn1 -- Transform5/LConn1 -- Transform6/LConn1 -- Transform7/LConn1 -- Transform8/LConn1 -- Transform9/LConn1
  Transform12/LConn1 -- F/RConn1
  Transform2/RConn1 -- x15060_M_01053_Plaquette_haute_sur_glissiere_SYM_AA_DEFAULT_1_R/LConn1
  Transform3/RConn1 -- x15060_NLM_Poign_e_Miniwing_M6_06652_006_X_15_1_RIGID/LConn1
  Transform4/RConn1 -- x15060_NLM_Goupille_cyl_3_Lgr_16_03320_03x16_AA_DEFAULT_2_RIGID/LConn1
  Transform5/RConn1 -- x15060_Rondelle_Rondelle_Etroite_Z_4_1_RIGID/LConn1
  Transform6/RConn1 -- x15060_M_01029_Plaquette_haute_sur_glissiere_AA_DEFAULT_1_RIGID/LConn1
  Transform7/RConn1 -- x15060_NLM_Poign_e_Miniwing_M6_06652_006_X_15_2_RIGID/LConn1
  Transform8/RConn1 -- x15060_M_01043_Bride_de_barre_AA_DEFAULT_1_RIGID/LConn1
  Transform9/RConn1 -- x15060_Rondelle_Rondelle_Etroite_Z_4_2_RIGID/LConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01030_Axe_long_pour_cardan_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.018832700000000001  MassUnits=kg  CenterOfMass=[10.180200000000001 0 0]  CenterOfMassUnits=mm  MomentsOfInertia=[3.3609800000000001 3.0386200000000003 4.4598800000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01030-Axe long pour cardan_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01030_Axe_long_pour_cardan_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.018832700000000001  MassUnits=kg  CenterOfMass=[10.180200000000001 0 0]  CenterOfMassUnits=mm  MomentsOfInertia=[3.3609800000000001 3.0386200000000003 4.4598800000000001]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01030-Axe long pour cardan_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01037_Plat_bord_de_cadre_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=1.8114600000000001  MassUnits=kg  CenterOfMass=[0.00025255699999999999 0.0067447599999999998 2.1860400000000002e-05]  CenterOfMassUnits=mm  MomentsOfInertia=[75398.300000000003 74453.099999999991 988.596]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00096463600000000005 -2.68862e-05 0.035765899999999996]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01037-Plat bord de cadre_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01038_Plat_bord_de_cadre_2_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=1.7491699999999999  MassUnits=kg  CenterOfMass=[-0.00091810799999999994 0.129633 0.12046900000000001]  CenterOfMassUnits=mm  MomentsOfInertia=[68228.600000000006 67317 953.67700000000002]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[9.3493700000000004 0.00019457900000000001 0.036298799999999999]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01038-Plat bord de cadre 2_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01040_Plat_bord_de_cadre_avt_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=1.8138099999999999  MassUnits=kg  CenterOfMass=[0.00023951299999999998 0.0067901899999999998 2.1832099999999997e-05]  CenterOfMassUnits=mm  MomentsOfInertia=[75185.100000000006 74242.899999999994 985.68099999999993]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00096463800000000008 -2.6885699999999999e-05 0.036499200000000002]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01040-Plat bord de cadre avt_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01044_Articulation_1_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.030893400000000001  MassUnits=kg  CenterOfMass=[30.2881 4.0547700000000004 5.6275700000000001e-05]  CenterOfMassUnits=mm  MomentsOfInertia=[2.8987799999999999 21.372799999999998 22.0291]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-1.1396899999999999e-05 2.8254700000000002e-05 2.2714599999999998]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01044-Articulation 1_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01044_Articulation_1_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.030893400000000001  MassUnits=kg  CenterOfMass=[30.2881 4.0547700000000004 5.6275700000000001e-05]  CenterOfMassUnits=mm  MomentsOfInertia=[2.8987799999999999 21.372799999999998 22.0291]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-1.1396899999999999e-05 2.8254700000000002e-05 2.2714599999999998]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01044-Articulation 1_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01046_Entretoise_pivot_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0013184899999999999  MassUnits=kg  CenterOfMass=[2.5 0 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.13452700000000001 0.070010300000000011 0.070010300000000011]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01046-Entretoise pivot_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01046_Entretoise_pivot_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0013184899999999999  MassUnits=kg  CenterOfMass=[2.5 0 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.13452700000000001 0.070010300000000011 0.070010300000000011]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01046-Entretoise pivot_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01057_Regle_gradu_e_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0040078800000000001  MassUnits=kg  CenterOfMass=[0.0045271199999999999 -0.21859200000000001 0.24951399999999999]  CenterOfMassUnits=mm  MomentsOfInertia=[36.349900000000005 0.027118099999999999 36.376899999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00018780900000000002 3.9843199999999998e-06 0.0014260500000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01057-Regle graduÚe_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01057_Regle_gradu_e_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0040078800000000001  MassUnits=kg  CenterOfMass=[0.0045271199999999999 -0.21859200000000001 0.24951399999999999]  CenterOfMassUnits=mm  MomentsOfInertia=[36.349900000000005 0.027118099999999999 36.376899999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00018780900000000002 3.9843199999999998e-06 0.0014260500000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01057-Regle graduÚe_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01057_Regle_gradu_e_AA_DEFAULT_3_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0040078800000000001  MassUnits=kg  CenterOfMass=[0.0045271199999999999 -0.21859200000000001 0.24951399999999999]  CenterOfMassUnits=mm  MomentsOfInertia=[36.349900000000005 0.027118099999999999 36.376899999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00018780900000000002 3.9843199999999998e-06 0.0014260500000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01057-Regle graduÚe_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01057_Regle_gradu_e_AA_DEFAULT_4_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0040078800000000001  MassUnits=kg  CenterOfMass=[0.0045271199999999999 -0.21859200000000001 0.24951399999999999]  CenterOfMassUnits=mm  MomentsOfInertia=[36.349900000000005 0.027118099999999999 36.376899999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.00018780900000000002 3.9843199999999998e-06 0.0014260500000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01057-Regle graduÚe_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01071_Rapporteur_angulaire_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0099800200000000009  MassUnits=kg  CenterOfMass=[32.323799999999999 -32.491899999999994 1.4859]  CenterOfMassUnits=mm  MomentsOfInertia=[3.4253 3.4290800000000004 6.8398000000000003]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-0.000193838 2.42873e-05 2.0103]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01071-Rapporteur angulaire_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01079_Plaque_a_trous_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.24485399999999999  MassUnits=kg  CenterOfMass=[0 -0.18249499999999999 2.5]  CenterOfMassUnits=mm  MomentsOfInertia=[203.56300000000002 734.41500000000008 936.95799999999986]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01079-Plaque a trous_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01079_Plaque_a_trous_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.24485399999999999  MassUnits=kg  CenterOfMass=[0 -0.18249499999999999 2.5]  CenterOfMassUnits=mm  MomentsOfInertia=[203.56300000000002 734.41500000000008 936.95799999999986]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01079-Plaque a trous_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01079_Plaque_a_trous_AA_DEFAULT_3_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.24485399999999999  MassUnits=kg  CenterOfMass=[0 -0.18249499999999999 2.5]  CenterOfMassUnits=mm  MomentsOfInertia=[203.56300000000002 734.41500000000008 936.95799999999986]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01079-Plaque a trous_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01002_Ens_cadre_Default_1_RIGID/x15060_M_01083_Plat_bord_de_cadre_2_SYM_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=1.7491699999999999  MassUnits=kg  CenterOfMass=[0.00093561799999999993 0.12959700000000002 0.12046900000000001]  CenterOfMassUnits=mm  MomentsOfInertia=[68228.699999999997 67317.100000000006 953.67999999999995]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[9.34938 0.00044111699999999998 -0.037077199999999998]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.898039 0.917647 0.929412]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01083-Plat bord de cadre 2 - SYM_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1
