simulink model "TableVerin4position2BO_Montee_S"  (R2013b)
settings: Solver=ode15s  StartTime=0.0  StopTime=20  RelTol=1e-3
undefined symbols (not defined in the file): deg, kg, m, mm, N, rad, s, X, Y, Z
libraries: sm_lib x907, fl_lib x19, nesl_utility x13, elec_lib x3, sdl_lib x2
(part 7 of 18)

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01014_Ens_plateau_Default_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Transform : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-925 0 43]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=2.0132360128362214  RotationArbitraryAxis=[0.54753194915001002 0.54753194915001013 0.63278553185102249]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform1 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-1105.79 374 -100.127]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=None  RotationAngleUnits=deg  RotationStandardAxis=+Z  RotationAngle=0  RotationArbitraryAxis=[0 0 1]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform10 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-1115 392.75 -110]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=2.583543076585459  RotationArbitraryAxis=[-0.67746529563212798 0.67746529563212843 -0.28649877212327818]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform11 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-925 300.5 43]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897918  RotationArbitraryAxis=[-7.0654109576159732e-16 -0.70710678118654657 -0.70710678118654846]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform12 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-810.678 9.8021700000000003 529.88]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=None  RotationAngleUnits=deg  RotationStandardAxis=+Z  RotationAngle=0  RotationArbitraryAxis=[0 0 1]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform2 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-1115 -395 -110]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897922  RotationArbitraryAxis=[-3.0711910248631515e-16 -0.70710678118654657 -0.70710678118654846]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform3 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-925 361 -15]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=2.0943951023931962  RotationArbitraryAxis=[0.57735026918962606 0.57735026918962606 0.57735026918962529]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform4 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[5.5511199999999999e-13 1.59872e-11 20]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=None  RotationAngleUnits=deg  RotationStandardAxis=+Z  RotationAngle=0  RotationArbitraryAxis=[0 0 1]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform5 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-1105.79 369 -100.127]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.6470564961270495  RotationArbitraryAxis=[-0.92650652227193386 -0.26606922425147794 -0.26606922425147816]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform6 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-962 375 -8.3266700000000001e-13]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.5707963267948992  RotationArbitraryAxis=[1 6.2800649999999829e-16 -7.7372349999999807e-16]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform7 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-925 -300.5 43]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897931  RotationArbitraryAxis=[9.8134400413412579e-17 -0.70710678118654713 -0.70710678118654791]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform8 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-1115 395 -110]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897927  RotationArbitraryAxis=[-5.050764743066142e-16 -0.70710678118654746 -0.70710678118654757]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform9 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-1115 -392.75 -110]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.7837363372751187  RotationArbitraryAxis=[-0.41768904582387023 -0.41768904582387045 0.8068901548522508]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  x15060_M_01003_Ens_structure_plateau_Default_1_RIGID : Subsystem
  x15060_M_01022_Plaque_sup_plateau_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01024_Cale_reglet_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01032_Porte_pivot_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01034_Axe_pivot_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01045_Articulation_2_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01045_Articulation_2_AA_DEFAULT_2_RIGID : Subsystem
  x15060_M_01065_Porte_pivot_SYM_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01072_Bloc_Rapporteur_angulaire_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01082_Axe_pivot_avt_AA_DEFAULT_1_RIGID : Subsystem
  x15060_M_01082_Axe_pivot_avt_AA_DEFAULT_2_RIGID : Subsystem
  x15060_Rondelle_Rondelle_TresLarge_LL_5_1_RIGID : Subsystem
  x15060_Vis_CHc_vis_CHc_M_5_X_8_1_RIGID : Subsystem
  F : PMIOPort  Port=1  Side=Right
  connections:
  Transform/RConn1 -- x15060_M_01034_Axe_pivot_AA_DEFAULT_1_RIGID/LConn1
  Transform1/RConn1 -- x15060_Rondelle_Rondelle_TresLarge_LL_5_1_RIGID/LConn1
  Transform10/RConn1 -- x15060_M_01082_Axe_pivot_avt_AA_DEFAULT_2_RIGID/LConn1
  Transform11/RConn1 -- x15060_M_01045_Articulation_2_AA_DEFAULT_2_RIGID/LConn1
  Transform/LConn1 -- ReferenceFrame/RConn1 -- Transform1/LConn1 -- Transform10/LConn1 -- Transform11/LConn1 -- Transform12/RConn1 -- Transform2/LConn1 -- Transform3/LConn1 -- Transform4/LConn1 -- Transform5/LConn1 -- Transform6/LConn1 -- Transform7/LConn1 -- Transform8/LConn1 -- Transform9/LConn1 -- x15060_M_01003_Ens_structure_plateau_Default_1_RIGID/RConn1
  Transform12/LConn1 -- F/RConn1
  Transform2/RConn1 -- x15060_M_01065_Porte_pivot_SYM_AA_DEFAULT_1_RIGID/LConn1
  Transform3/RConn1 -- x15060_M_01072_Bloc_Rapporteur_angulaire_AA_DEFAULT_1_RIGID/LConn1
  Transform4/RConn1 -- x15060_M_01022_Plaque_sup_plateau_AA_DEFAULT_1_RIGID/LConn1
  Transform5/RConn1 -- x15060_Vis_CHc_vis_CHc_M_5_X_8_1_RIGID/LConn1
  Transform6/RConn1 -- x15060_M_01024_Cale_reglet_AA_DEFAULT_1_RIGID/LConn1
  Transform7/RConn1 -- x15060_M_01045_Articulation_2_AA_DEFAULT_1_RIGID/LConn1
  Transform8/RConn1 -- x15060_M_01032_Porte_pivot_AA_DEFAULT_1_RIGID/LConn1
  Transform9/RConn1 -- x15060_M_01082_Axe_pivot_avt_AA_DEFAULT_1_RIGID/LConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/table_1_RIGID/x15060_M_01018_Ch_ssis_haut_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Transform : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-236.267 -112 215]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=None  RotationAngleUnits=deg  RotationStandardAxis=+Z  RotationAngle=0  RotationArbitraryAxis=[0 0 1]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform1 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-236.267 -160 215]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.6989856875068772  RotationArbitraryAxis=[0.33667237369942338 0.33667237369942338 0.87937672562741365]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform2 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-316.267 0 341.5]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897931  RotationArbitraryAxis=[3.9495849999999997e-15 -1.2551650000000001e-16 1]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform3 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-301.54399999999998 129.20000000000002 358.5]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=1.5783131041085721  RotationArbitraryAxis=[0.9925113327479933 0.086374922190420325 -0.086374922190420325]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform4 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-301.54399999999998 123.2 358.5]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=ArbitraryAxis  RotationAngleUnits=rad  RotationStandardAxis=+Z  RotationAngle=3.1415926535897931  RotationArbitraryAxis=[-0.9966372618178484 -2.069506358459949e-16 0.081940029022581309]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  Transform5 : sm_lib/Frames and Transforms/Rigid Transform  TranslationMethod=Cartesian  TranslationLengthUnit=mm  TranslationStandardAxis=+Z  TranslationStandardOffset=0  TranslationCartesianOffset=[-601.91099999999994 7.3021699999999994 169.88]  TranslationROffset=0  TranslationROffsetUnits=m  TranslationZOffset=0  TranslationZOffsetUnits=m  TranslationThetaOffset=0  TranslationThetaOffsetUnits=deg  RotationMethod=None  RotationAngleUnits=deg  RotationStandardAxis=+Z  RotationAngle=0  RotationArbitraryAxis=[0 0 1]  FollAlignAxisA=+X  BaseAlignAxisA=+Y  FollAlignAxisB=+Y  BaseAlignAxisB=+Z  BlockFunction=simmechanics.library.frames_transforms.rigid_transform
  x15060_Ecrou_22_Ecrou_Hm_M12_2_RIGID : Subsystem
  x15060_M_01015_Ens_verin_levage_Default_1_RIGID : Subsystem
  x15060_M_01016_Ens_verin_inclinaison_Default_1_RIGID : Subsystem
  x15060_M_01025_Chape_sous_plateau_AA_DEFAULT_1_RIGID : Subsystem
  x15060_NLM_Vis_CHc_rectifi_e_a_paulement_16_L40_M12_07534_16x40 : Subsystem
  x15060_Rondelle_Rondelle_TresLarge_LL_6_1_RIGID : Subsystem
  x15060_Vis_CHc_vis_CHc_M_6_X_10_1_RIGID : Subsystem
  F : PMIOPort  Port=1  Side=Right
  connections:
  Transform/RConn1 -- x15060_Ecrou_22_Ecrou_Hm_M12_2_RIGID/LConn1
  Transform1/RConn1 -- x15060_NLM_Vis_CHc_rectifi_e_a_paulement_16_L40_M12_07534_16x40/LConn1
  Transform2/RConn1 -- x15060_M_01025_Chape_sous_plateau_AA_DEFAULT_1_RIGID/LConn1
  Transform3/RConn1 -- x15060_Vis_CHc_vis_CHc_M_6_X_10_1_RIGID/LConn1
  Transform4/RConn1 -- x15060_Rondelle_Rondelle_TresLarge_LL_6_1_RIGID/LConn1
  Transform/LConn1 -- ReferenceFrame/RConn1 -- Transform1/LConn1 -- Transform2/LConn1 -- Transform3/LConn1 -- Transform4/LConn1 -- Transform5/RConn1 -- x15060_M_01015_Ens_verin_levage_Default_1_RIGID/RConn1 -- x15060_M_01016_Ens_verin_inclinaison_Default_1_RIGID/RConn1
  Transform5/LConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_MEAS_Capteur_deffort_1000_N_FN_9620_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.055743500000000001  MassUnits=kg  CenterOfMass=[-0.26206499999999999 -30 0.033814799999999999]  CenterOfMassUnits=mm  MomentsOfInertia=[17.2349 16.760199999999998 30.043899999999997]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 -0.057939600000000001 0.30096000000000001]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-MEAS-Capteur d''effort 1000 N - FN 9620_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01035_Pied_porte_capteur_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.014384600000000001  MassUnits=kg  CenterOfMass=[0 43.020600000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[9.3602100000000004 0.40735199999999999 9.3478899999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01035-Pied porte capteur_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01039_Plaque_roulette_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.43894300000000003  MassUnits=kg  CenterOfMass=[-25.4345 -25.5169 7.70458]  CenterOfMassUnits=mm  MomentsOfInertia=[1154.4699999999998 1151.76 2290.0799999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-5.9034899999999997 -5.9108999999999998 -90.315899999999999]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01039-Plaque roulette_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01063_Rondelle_entretoise_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0012337000000000001  MassUnits=kg  CenterOfMass=[0 0.5 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.046058299999999996 0.091910900000000004 0.046058299999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01063-Rondelle entretoise_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01063_Rondelle_entretoise_AA_DEFAULT_2_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0012337000000000001  MassUnits=kg  CenterOfMass=[0 0.5 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.046058299999999996 0.091910900000000004 0.046058299999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01063-Rondelle entretoise_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01063_Rondelle_entretoise_AA_DEFAULT_3_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0012337000000000001  MassUnits=kg  CenterOfMass=[0 0.5 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.046058299999999996 0.091910900000000004 0.046058299999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01063-Rondelle entretoise_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01063_Rondelle_entretoise_AA_DEFAULT_4_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0012337000000000001  MassUnits=kg  CenterOfMass=[0 0.5 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.046058299999999996 0.091910900000000004 0.046058299999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01063-Rondelle entretoise_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01063_Rondelle_entretoise_AA_DEFAULT_5_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0012337000000000001  MassUnits=kg  CenterOfMass=[0 0.5 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.046058299999999996 0.091910900000000004 0.046058299999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01063-Rondelle entretoise_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01069_Bride_doigt_dindexage_AA_DEFAULT_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.014447099999999999  MassUnits=kg  CenterOfMass=[4.4069700000000003 -2.6008199999999997 -4.1192499999999998e-07]  CenterOfMassUnits=mm  MomentsOfInertia=[1.8820299999999999 2.6811400000000001 3.4835000000000003]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-6.5011099999999991e-08 -4.9180400000000003e-08 -0.603711]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01069-Bride doigt d''indexage_AA - DEFAULT_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_M_01075_Broche_M12_Modifi_e_27810_120451_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0047747900000000001  MassUnits=kg  CenterOfMass=[-3.6256400000000002 5.7239899999999995e-11 9.2095899999999998e-10]  CenterOfMassUnits=mm  MomentsOfInertia=[0.104488 0.560944 0.56094299999999997]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-M-01075-Broche M12 ModifiÚe - 27810-120451_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_NLM_Doigt_dindexage_acier_6_avec_contre_ecrou_M12x1_5_03 ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0088640300000000002  MassUnits=kg  CenterOfMass=[0 31.310499999999998 0]  CenterOfMassUnits=mm  MomentsOfInertia=[2.5645000000000002 0.33363399999999999 2.5645000000000002]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-NLM-Doigt d''indexage acier Ï6 avec contre ecrou M12x1.5  - 03089-2206_AA - DEFAULT_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_NLM_Embase_60_27801_20601_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0412567  MassUnits=kg  CenterOfMass=[3.1516899999999996e-05 6.0550100000000002 0]  CenterOfMassUnits=mm  MomentsOfInertia=[9.1015499999999996 16.328600000000002 9.1015499999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 5.7797099999999998e-06]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Embase Ï 60 - 27801-20601_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_NLM_Roulette_pivotante_F_200_KG_95034_07532_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.14865700000000001  MassUnits=kg  CenterOfMass=[18.544499999999999 28.657700000000002 2.3950599999999997e-05]  CenterOfMassUnits=mm  MomentsOfInertia=[170.20699999999999 146.78099999999998 227.70599999999999]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[-5.38496e-05 -0.00156548 63.646399999999993]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Roulette pivotante F 200 KG - 95034-07532_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_NLM_Verin_a_levier_Rot_a_droite_traction_04410_35_1_RIGI ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.147758  MassUnits=kg  CenterOfMass=[-26.9514 18.9069 18.9069]  CenterOfMassUnits=mm  MomentsOfInertia=[376.55899999999997 216.44699999999997 216.44699999999997]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[165.25200000000001 2.65794 2.65794]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-NLM-Verin a levier - Rot a droite - traction - 04410-35_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_Rondelle_Rondelle_Large_L_6_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.00026675899999999998  MassUnits=kg  CenterOfMass=[0 0.60000000000000009 0]  CenterOfMassUnits=mm  MomentsOfInertia=[0.0061167799999999996 0.0121695 0.0061167799999999996]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 0]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.792157 0.819608 0.933333]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName=15060-Rondelle-_Rondelle Large L 6_Défaut_sldprt.STL  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1

== system TableVerin4position2BO_Montee_S/Modèle mécanique/base_1_RIGID/x15060_M_01006_Ens_pied_escamotable_Default_1_RIGID/x15060_Vis_CHc_vis_CHc_M_5_X_20_1_RIGID ==
  ReferenceFrame : sm_lib/Frames and Transforms/Reference Frame  BlockFunction=simmechanics.library.frames_transforms.reference_frame
  Solid : sm_lib/Body Elements/Solid  InertiaType=Custom  Mass=0.0048238700000000001  MassUnits=kg  CenterOfMass=[0 1.34757e-08 10.3775]  CenterOfMassUnits=mm  MomentsOfInertia=[0.28694200000000003 0.28696100000000002 0.0276957]  MomentsOfInertiaUnits=kg*mm^2  ProductsOfInertia=[0 0 -1.2488400000000001e-06]  ProductsOfInertiaUnits=kg*mm^2  DensityBased=on  Density=1000  DensityUnits=kg/(m^3)  GraphicType=FromGeometry  MarkerShape=Sphere  MarkerSize=10  MarkerSizeUnits=m  GraphicVisPropType=SimpleVisualProperties  GraphicDiffuseColor=[0.776471 0.756863 0.737255]  GraphicSpecularColor=[0.5 0.5 0.5 1.0]  GraphicAmbientColor=[0.15 0.15 0.15 1.0]  GraphicEmissiveColor=[0.0 0.0 0.0 1.0]  GraphicShininess=75  GraphicOpacity=1  GeometryShape=FromFile  RectangleSize=[1 1]  RectangleSizeUnits=m  BrickDimensions=[1 1 1]  BrickDimensionUnits=m  CylinderRadius=1  CylinderRadiusUnits=m  CylinderLength=1  CylinderLengthUnits=m  SphereRadius=1  SphereRadiusUnits=m  EllipsoidRadii=[1 1 1]  EllipsoidRadiiUnits=m  ExtrusionCrossSection=[1 1; -1 1; -1 -1; 1 -1]  ExtrusionCrossSectionUnits=m  ExtrusionLength=1  ExtrusionLengthUnits=m  PolygonNumSides=3  PolygonOuterRadius=1  PolygonOuterRadiusUnits=m  ExtGeomFileName="15060-Vis CHc-_vis CHc M 5 X  20_Défaut_sldprt.STL"  ExtGeomFileUnits=mm  RevolutionCrossSection=[1 1; 1 -1; 2 -1; 2 1]  RevolutionCrossSectionUnits=m  RevolutionExtent=Full  RevolutionAngle=180  RevolutionAngleUnits=deg  BlockFunction=simmechanics.library.body_elements.solid
  F : PMIOPort  Port=1  Side=Left
  connections:
  Solid/RConn1 -- ReferenceFrame/RConn1 -- F/RConn1
